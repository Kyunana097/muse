# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Headers;.\sources
  group Source Group 1
    ./: main.c
    ./Headers/: oledfont.h bmp.h music.h Delay.h oled.h note.h
    ./sources/: oledfont.c music.c Delay.c oled.c note.c
